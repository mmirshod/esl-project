<?xml version="1.0" encoding="iso-8859-1"?>

<workspace> <project>
    <path>$WS_DIR$\pca10059\mbr\iar\blinky_pca10059_mbr.ewp</path>
  </project>
</workspace>